# IAR project softtimer_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429IG ST STM32F429IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx
  ICCARM.CCIncludePath2: ..\..\Drivers\CFG; ..\User; ..\User\ISR; ..\..\Drivers\CMSIS; ..\..\Drivers\STM32F4xx_HAL_Driver\lnc; ..\..\BSP; ..\..\Middlewaers\uCOSIII\uC-CONFIG; ..\..\Middlewaers\uCOSIII\uC-CPU; ..\..\Middlewaers\uCOSIII\uC-LIB; ..\..\Middlewaers\uCOSIII\uC-OS3
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: pend_demo.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application/EWARM
    ../User/: startup_stm32f429xx.s
  group Application/User
    ../User/: main.c
  group Application/User/ISR
    ../User/ISR/: stm32f4xx_it.c
  group Application/User/Task
    ../User/Task/: start_task.c task_key.c task_softtimer.c
  group BSP
    ../../BSP/: bsp_delay.c bsp_led_key_exti.c bsp_uart.c
  group Drivers/CFG
    ../../Drivers/CFG/: stm32f4xx_hal_conf.h stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c
  group Middlewares/uCOSIII/uC-CONFIG
    ../../Middlewaers/uCOSIII/uC-CONFIG/: os_app_hooks.c
  group Middlewares/uCOSIII/uC-CPU
    ../../Middlewaers/uCOSIII/uC-CPU/: bsp_cpu.c cpu_a.asm cpu_c.c cpu_core.c
  group Middlewares/uCOSIII/uC-LIB
    ../../Middlewaers/uCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_mem_a.asm lib_str.c
  group Middlewares/uCOSIII/uC-OS3
    ../../Middlewaers/uCOSIII/uC-OS3/: bsp_os_dt.c os_cfg_app.c os_core.c os_cpu_a.asm os_cpu_c.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
